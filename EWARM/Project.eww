<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CKB-STM32-MSC-Standalone-U5.ewp</path>
  </project>
  <batchBuild />
</workspace>
