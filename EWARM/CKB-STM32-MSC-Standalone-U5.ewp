# IAR project CKB-STM32-MSC-Standalone-U5.ewp, settings and files
configuration CKB-STM32-MSC-Standalone-U5 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U5G9NJ ST STM32U5G9NJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U5G9xx; UX_INCLUDE_USER_DEFINE_FILE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../USBX/App; ../USBX/Target; ../Middlewares/ST/usbx/common/core/inc; ../Middlewares/ST/usbx/ports/generic/inc; ../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../Middlewares/ST/usbx/common/usbx_device_classes/inc; ..\Drivers\BSP\STM32U5x9J-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CKB-STM32-MSC-Standalone-U5.hex
  ILINK.IlinkOutputFile: CKB-STM32-MSC-Standalone-U5.out
  ILINK.IlinkIcfFile: stm32u5g9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u5g9xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c icache.c main.c stm32u5xx_hal_msp.c stm32u5xx_it.c usb_otg.c
  group Application/User/USBX/App
    ../USBX/App/: app_usbx_device.c ux_device_descriptors.c ux_device_msc.c
  group Drivers/BSP
    ../Drivers/BSP/STM32U5x9J-DK/: stm32u5x9j_discovery_mmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_sdio.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Middlewares/USBX/Core System
    ../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_set.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/UX Device Class MSC
    ../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_storage_activate.c ux_device_class_storage_control_request.c ux_device_class_storage_csw_send.c ux_device_class_storage_deactivate.c ux_device_class_storage_entry.c ux_device_class_storage_format.c ux_device_class_storage_get_configuration.c ux_device_class_storage_get_performance.c ux_device_class_storage_get_status_notification.c ux_device_class_storage_initialize.c ux_device_class_storage_inquiry.c ux_device_class_storage_mode_select.c ux_device_class_storage_mode_sense.c ux_device_class_storage_prevent_allow_media_removal.c ux_device_class_storage_read.c ux_device_class_storage_read_capacity.c ux_device_class_storage_read_disk_information.c ux_device_class_storage_read_dvd_structure.c ux_device_class_storage_read_format_capacity.c ux_device_class_storage_read_toc.c ux_device_class_storage_report_key.c ux_device_class_storage_request_sense.c ux_device_class_storage_start_stop.c ux_device_class_storage_synchronize_cache.c ux_device_class_storage_tasks_run.c ux_device_class_storage_test_ready.c ux_device_class_storage_uninitialize.c ux_device_class_storage_verify.c ux_device_class_storage_write.c
  group Middlewares/USBX/UX Device Controllers
    ../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c
